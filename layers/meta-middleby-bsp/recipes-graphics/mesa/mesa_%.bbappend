PACKAGECONFIG:append = " lima panfrost"
GALLIUMDRIVERS:append = ",kmsro"
