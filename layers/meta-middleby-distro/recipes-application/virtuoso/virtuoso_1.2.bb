include virtuoso.inc

RDEPENDS:${PN} += "qtsvg"
