PACKAGECONFIG:class-nativesdk += "dri3 egl gbm"
