PACKAGECONFIG:append = " fontconfig eglfs gles2 accessibility linuxfb gif jpeg libpng dbus kms gbm "
